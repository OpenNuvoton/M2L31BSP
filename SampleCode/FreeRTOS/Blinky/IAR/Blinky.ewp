# IAR project Blinky.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2L31 series Nuvoton M2L31 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M2L31\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FreeRTOS\Source\include; ..\..\..\..\ThirdParty\FreeRTOS\Source\portable\IAR\ARM_CM23_NTZ\non_secure; ..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\Library\Device\Nuvoton\M2L31\Include; $PROJ_DIR$..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\..\..\ThirdParty\FreeRTOS\SOURCE\include; $PROJ_DIR$..\..\
  OBJCOPY.OOCOutputFile: Blinky.bin
  ILINK.IlinkOutputFile: Blinky.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2L31/Source/IAR/: startup_M2L31.s
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
  group FreeRTOS files
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM23_NTZ/non_secure/: port.c portasm.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: flash.c PollQ.c QueueSet.c
    ../: main.c ParTest.c
