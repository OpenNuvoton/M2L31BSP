# Keil uVision project Blinky.uvprojx, settings and files
target FreeRTOS (6190000::V6.19::ARMCLANG)
  device: M2L31KGDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000,0x2a000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: Blinky
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M2L31\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM23_NTZ\non_secure;..\..\Blinky
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x2a000
  link misc: --map --first='startup_M2L31.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group System
    ../../../../Library/Device/Nuvoton/M2L31/Source/ARM/: startup_M2L31.s
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
  group Demo Files
    ../: main.c ParTest.c
    ../../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: QueueSet.c flash.c PollQ.c
  group FreeRTOS files
    ../../../../ThirdParty/FreeRTOS/Source/: tasks.c timers.c list.c queue.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM23_NTZ/non_secure/: port.c portasm.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group lib
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c gpio.c
