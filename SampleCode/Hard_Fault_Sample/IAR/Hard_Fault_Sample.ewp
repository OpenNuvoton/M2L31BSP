# IAR project Hard_Fault_Sample.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2L31 series Nuvoton M2L31 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\Device\Nuvoton\M2L31\Include; ..\..\..\Library\StdDriver\Inc; ..\..\..\Library\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Hard_Fault_Sample.bin
  ILINK.IlinkOutputFile: Hard_Fault_Sample.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M2L31/Source/IAR/: startup_M2L31.s
    ../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../: main.c
