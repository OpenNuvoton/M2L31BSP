# Keil uVision project ISP_MSC.uvprojx, settings and files
target ISP_MSC (6120000::V6.12::.\ARMCLANG)
  device: M2L31KIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.19
  cpu: IRAM(0x20000000,0x2A000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: ISP_MSC
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\Device\Nuvoton\M2L31\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x2a000
  link misc: --map --first='startup_M2L31_user.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../: system_M2L31_user.c startup_M2L31_user.s
  group User
    ../: usbd_User.c MassStorage.c descriptors.c DataFlashProg.c main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c
software components: CMSIS:CORE 5.2.0
