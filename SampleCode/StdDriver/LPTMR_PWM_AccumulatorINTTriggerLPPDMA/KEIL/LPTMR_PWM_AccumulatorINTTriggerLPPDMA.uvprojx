# Keil uVision project LPTMR_PWM_AccumulatorINTTriggerLPPDMA.uvprojx, settings and files
target LPTMR_PWM_AccumulatorINTTriggerLPPDMA (6120000::V6.12::.\ARMCLANG)
  device: M2L31KIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.19
  cpu: IRAM(0x20000000,0x2A000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: LPTMR_PWM_AccumulatorINTTriggerLPPDMA
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M2L31\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x2a000
  memory RVCT10: RAM 0x28000000 size 0x2000
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2L31/Source/ARM/: startup_M2L31.s
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c lptmr_pwm.c lppdma.c
