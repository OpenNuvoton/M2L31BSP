# IAR project USBD_HID_Transfer_And_MSC.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2L31 series Nuvoton M2L31 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082, Pe177
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M2L31\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\StdDriver\src; ..\..\..\..\Library\PowerDeliveryLib\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_HID_Transfer_And_MSC.bin
  ILINK.IlinkOutputFile: USBD_HID_Transfer_And_MSC.out
  ILINK.IlinkIcfFile: USBD_HID_Transfer_And_MSC.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2L31/Source/IAR/: startup_M2L31.s
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c usbd.c
  group User
    ../: descriptors.c hid_transfer_And_MSC.c main.c
