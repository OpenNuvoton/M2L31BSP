# Keil uVision project USBD_Mass_Storage_CDROM.uvprojx, settings and files
target USBD_Mass_Storage_CDROM (6120000::V6.12::.\ARMCLANG)
  device: M2L31KIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.19
  cpu: IRAM(0x20000000,0x2A000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: USBD_Mass_Storage_CDROM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M2L31\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x2a000
  link misc: --map --first='startup_M2L31.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
    ../../../../Library/Device/Nuvoton/M2L31/Source/ARM/: startup_M2L31.s
  group User
    ../: main.c descriptors.c MassStorage.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usbd.c sys.c clk.c uart.c
  group DiskImage
    ../: DiskImg.c
