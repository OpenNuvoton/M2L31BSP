# IAR project UTCPD_SourceRole.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2L31 series Nuvoton M2L31 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: OPT_SRC_ONLY=1; OPT_SNK_ONLY=0; DEBUG_PORT=UART0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M2L31\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\PowerDeliveryLib\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UTCPD_SourceRole.bin
  ILINK.IlinkOutputFile: UTCPD_SourceRole.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2L31/Source/IAR/: startup_M2L31.s
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
  group Library
    ../../../../Library/StdDriver/src/: acmp.c clk.c eadc.c gpio.c retarget.c sys.c timer.c uart.c utcpd.c
    ../../../../Library/PowerDeliveryLib/: PD_SRC.a
  group User
    ../: commandshell.c ec_adc.c main.c usb_MultipleFunction.c usb_pd_policy.c usb_powerctrl.c
