# Keil uVision project UTCPD_SourceRole.uvprojx, settings and files
target UTCPD_SourceRole (6130001::V6.13.1::.\ARMCLANG)
  device: M2L31KIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.19
  cpu: IRAM(0x20000000,0x2A000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: UTCPD_SourceRole
  AfterMake: fromelf --bin ".\obj\Transmit\@L.axf" --output ".\obj\Transmit\@L.bin"
  AfterMake: fromelf --text -c ".\obj\Transmit\@L.axf" --output ".\obj\Transmit\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=1
  c define: OPT_SRC_ONLY=1, OPT_SNK_ONLY=0 DEBUG_PORT=UART0
  c misc: --specs=nosys.specs
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M2L31\Include;..\..\..\..\Library\PowerDeliveryLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x2a000
  link misc: --map --first='startup_M2L31.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2L31/Source/: system_M2L31.c
    ../../../../Library/Device/Nuvoton/M2L31/Source/ARM/: startup_M2L31.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c timer.c gpio.c eadc.c acmp.c utcpd.c
    ../../../../Library/PowerDeliveryLib/: PD_SRC.lib
  group User
    ../: main.c usb_pd_policy.c usb_powerctrl.c usb_MultipleFunction.c ec_adc.c commandshell.c
